# Keil uVision project YumairFP01.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YumairFP01 +hex
  AfterMake: xcopy Objects\*.hex Firmware /Y
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o Firmware/YumairFP01.bin Objects/YumairFP01.axf
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\hal;..\lib\inc;..\sys;..\usr
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group usr
    ../usr/: main.c GPRS.c HTTPRequest.c YumairPrivate.c YumairProtocol.c testProtocol.c MD5.c
  group hal
    ../hal/: HalCommon.c HalUart.c HalGPIO.c HalTimer.c HalFlash.c
  group sys
    ../sys/: Sys.c SysTimer.c
  group lib
    ../lib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
